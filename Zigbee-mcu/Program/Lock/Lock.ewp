# IAR project Lock.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ; Driver; Device; AppHigh; AppLow
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: Congfig.h main.c
  group AppHigh
    AppHigh/: Card.c CC2530.c Door.c
  group AppLow
    AppLow/: Data.c Warn.c
  group Device
    Device/: AT24C256.c MFRC522.c PCF8563.c
  group Driver
    Driver/: Adc.c Buzzer.c I2c.c Key.c Led.c Motor.c Rf.c Sleep.c Spi.c Sysclk.c Timer.c Wdt.c
